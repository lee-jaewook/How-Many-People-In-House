# Keil uVision project HowManyPeople.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TicTacToe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Huins_NXP_LPC1768_Library\Drivers\include;C:\Keil_v5\ARM\CMSIS\Include;..\11_Keypad;..\14_LCD_Test;..\Huins_NXP_LPC1768_Library\Core\Device\NXP\LPC17xx\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ../1_GPIO/GPIO1/MDK-ARM/: system_LPC17xx.c startup_LPC17xx.s
  group Source
    ../Huins_NXP_LPC1768_Library/Drivers/source/: lpc17xx_gpio.c lpc17xx_pinsel.c LPC1768_utility.c
  group Main
    ../14_LCD_Test/: GLCD.c
    ./: ANH.c
